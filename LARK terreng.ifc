Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Alignment-basedView]
File name: O:\26093\F_Prosjektdokumenter\1 Tegninger\6 Civil 3d\06_Eksport\IFC\Punkthøyder og fallforhold til eksport 3d-dwg 22.09.2026.ifc
Time: 2026-09-22T09:28:44
Author: gm
Organization: STAERK
Written by: GeometryGymIFCcore v25.2.25.0 by Geometry Gym Pty Ltd built 2025-02-25T02:37:52
Made in: Autodesk - Civil 3D 2025 IfcInfra Plugin - 13.7.235.0
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, Unknown
Classification: Civil 3D
Summary - Subject: Focus CAT Basis 2016; Comments: Versjon 16.1

# IfcAnnotation (2)
In: UnknownName
Properties - CloneMeForDragging: yes; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no; Closed: no; HasBulges: no; HasWidth: no; IsOnlyLines: yes; NumberOfVertices: 2; Plinegen: no
Geometry - Elevation: 0; ConstantWidth: 0; Length: 6.50605; IsPeriodic: no; IsPlanar: yes
General - ColorIndex: 256; LinetypeScale: 1; PlotStyleName: ByLayer; Visible: yes; Thickness: 0; Layer: 0; Linetype: Continuous
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - Material: ByLayer; CastShadows: no; ReceiveShadows: no
Name | Bounds
 | ((470916.7133257342,6514610.686284928,0),(470921.2866742658,6514615.313715072,0))
 | ((470916.68874962913,6514610.710834571,0),(470921.31125037087,6514615.289165429,0))

# IfcAnnotation: CogoPoint, IFC Project Base Point
In: UnknownName
Description: IFC Project Base Point; Classification: Generell (Point Styles)
C3D_Attributes - PointNumber: 1
Properties - Easting: 470919; Elevation: 0; ElevationOverride: 0; FullDescription: IFC Project Base Point; FullDescriptionOverride: IFC Project Base Point; IsCheckedOut: no; IsLabelDragged: no; IsLabelPinned: no; IsLabelVisible: yes; IsLocked: no; IsMovable: yes; IsProjectPoint: no; IsSurveyPoint: no; LabelRotation: 0; MarkerRotation: 0; Northing: 6514613; PointName: IFC Project Base Point; PointNumber: 1; RawDescription: IFC Project Base Point; RawDescriptionOverride: IFC Project Base Point; ScaleXY: 1; ScaleZ: 1; ShowToolTip: yes; CloneMeForDragging: yes; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; Bounds: ((470917.2039487758,6514609.9375,0),(470942.2730256121,6514615.8125,0)); AutoDelete: no; IsDisposed: no
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
General - ColorIndex: 256; Layer: C3D - PUNKT; Linetype: ByLayer; LinetypeScale: 1; PlotStyleName: ByLayer; Visible: yes
Geometry - IsPlanar: no

# IfcBuiltElement, CT - Terrengmodell TIN
In: UnknownName
Properties - CloneMeForDragging: yes; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no; Area: 3448.43; IsNull: no; NumChanges: 1; RecordHistory: no; ShowHistory: no; UsesGraphicsCache: yes; Bounds: ((470884.46977942856,6514640.5977286585,192.75999999977648),(470954.0676602591,6514711.3100000005,196))
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
General - ColorIndex: 256; Linetype: ByLayer; LinetypeScale: 1; PlotStyleName: ByLayer; Visible: yes; Layer: CT - Terrengmodell TIN
Geometry - IsPlanar: no
